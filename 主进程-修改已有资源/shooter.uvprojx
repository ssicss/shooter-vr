# Keil uVision project shooter.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: STM32F303VC STMicroelectronics
  pack: Keil.STM32F3xx_DFP.1.3.0
  cpu: IROM(0x08000000,0x00040000) IRAM(0x20000000,0x0000C000) IRAM2(0x10000000,0x00002000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: shooter
  c flags: Optim=1 OneElfS=1 wLevel=2
  c include: .\inc;.\Libraries\CMSIS\Include;.\Libraries\CMSIS\Device\ST\STM32F30x\Include;.\Libraries\STM32F30x_StdPeriph_Driver\inc;.\Libraries\STM32F3_Discovery;.\Libraries\STM32_USB-FS-Device_Driver\inc;.\Libraries\shooter\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  memory RVCT10: RAM 0x10000000 size 0x2000
  group src
    ./src/: hw_config.c main.c peripherals.c stm32f30x_it.c system_stm32f30x.c usb_desc.c usb_endp.c usb_istr.c usb_prop.c usb_pwr.c
  group lib/shooter
    ./Libraries/shooter/src/: bsp.c JX_Eeprom.c tc358870data.c
  group lib/cmsis
    ./Libraries/CMSIS/Device/ST/STM32F30x/Source/Templates/arm/: startup_stm32f30x.s
  group lib/usb
    ./Libraries/STM32_USB-FS-Device_Driver/src/: usb_core.c usb_init.c usb_int.c usb_mem.c usb_regs.c usb_sil.c
  group lib/bsp
    ./Libraries/STM32F3_Discovery/: stm32f3_discovery.c stm32f3_discovery_l3gd20.c stm32f3_discovery_lsm303dlhc.c
  group lib/stdp
    ./Libraries/STM32F30x_StdPeriph_Driver/src/: stm32f30x_adc.c stm32f30x_can.c stm32f30x_comp.c stm32f30x_crc.c stm32f30x_dac.c stm32f30x_dbgmcu.c stm32f30x_dma.c stm32f30x_exti.c stm32f30x_flash.c stm32f30x_gpio.c stm32f30x_i2c.c stm32f30x_iwdg.c stm32f30x_misc.c stm32f30x_opamp.c stm32f30x_pwr.c stm32f30x_rcc.c stm32f30x_rtc.c stm32f30x_spi.c stm32f30x_syscfg.c stm32f30x_tim.c stm32f30x_usart.c stm32f30x_wwdg.c
